# Keil uVision project USB2CAN2015.uvprojx, settings and files
target STM32F103CBT6 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB2CAN2015
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\app\inc;.\driver\inc;.\FreeRTOS\include;.\FreeRTOS;.\FreeRTOS\port;.\lib\inc;.\sys
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./app/src/: canopen.c cli.c
  group sys
    ./sys/: core_cm3.c main.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/port/: port.c
    ./FreeRTOS/MemMang/: heap_2.c
  group lib
    ./lib/src/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group driver
    ./driver/src/: can.c led.c sci.c
